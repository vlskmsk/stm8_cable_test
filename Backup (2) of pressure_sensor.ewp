# IAR project Backup (2) of pressure_sensor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c mpl115a1.c spi.c system.c uart.c
  group Driver
    ./: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_spi.c stm8s_tim1.c stm8s_tim4.c stm8s_uart1.c
  group inc
    ./: mpl115a1.h stm8s.h stm8s_adc1.h stm8s_clk.h stm8s_conf.h stm8s_gpio.h stm8s_spi.h stm8s_tim1.h stm8s_tim4.h stm8s_uart1.h
